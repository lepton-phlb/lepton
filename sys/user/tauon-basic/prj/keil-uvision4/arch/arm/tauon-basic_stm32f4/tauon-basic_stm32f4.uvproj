# Keil uVision project tauon-basic_stm32f4.uvproj, settings and files
target tauon-basic_stm32f407ZG (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: tauon-basic_stm32f4
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/net/uip2.5;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/arch/cmsis/DeviceSupport_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sys/root/kernel/core/arch/ucore/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_386_keil/arch/cmsis/DeviceSupport_CM4F/: system_ARMCM4.h ARMCM4.h startup_ARMCM4.s system_ARMCM4.c
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_386_keil/arch/cmsis/: main.c
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/startup/keil/: system_stm32f4xx.h system_stm32f4xx.c startup_stm32f4xx.s
  group sys/root/kernel/core/arch/ucore/embos
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_386_keil/lib/: osT7VLSP.lib
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_386_keil/arch/cmsis/cpu/: Retarget.c JLINKMEM_Process.c OS_Error.c OS_InitSysStackInfo.c RTOSInit_CMSIS_CM4F.c
  group sys/root/kernel/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: dev_mkconf.c bin_mkconf.c dev_dskimg.c
  group lib
    ../../../../../../../root/prj/keil-uvision4/dev/: dev.lib
    ../../../../../../../root/prj/keil-uvision4/fs/: fs.lib
    ../../../../../../../root/prj/keil-uvision4/kernel/: kernel.lib
    ../../../../../../../root/prj/keil-uvision4/lib/: lib.lib
    ../../../../../../../root/prj/keil-uvision4/net-uip/: net-uip.lib
    ../../../../../../../root/prj/keil-uvision4/sbin/: sbin.lib
  group bin/dhrystone
    ../../../../../src/bin/dhrystone/: timers.c dhry21a.c dhry21b.c dhry.h dhrystone_main.c dhrystone_main.h
  group bin/free
    ../../../../../src/bin/free/: dlmalloc.c free_main.c
  group bin/sdramtest
    ../../../../../src/bin/sdramtest/: sdramtest_main.c
  group bin
    ../../../../../../../root/src/bin/: udpsrvd.c
