# IAR project tauon_at91sam9261_7.20.ewp, settings and files
configuration firmware (ARM)
  General.OGChipSelectEditMenu: AT91M55800 Atmel AT91M55800
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP
  ICCARM.CCDiagSuppress: pe001,pe375,pe231,pe177
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7-9_388/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TARGET_RAM
  ILINK.IlinkOutputFile: tauon_at91sam9261.out
configuration firmware_injector (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM9261 Atmel AT91SAM9261
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG; SDRAM_TARGET=1
  ICCARM.CCDiagSuppress: pe001, pe375, pe177, pa050,Pe167
  ICCARM.CCOptLevel: 0
  AARM.ADefines: TARGET_JTAG
  OBJCOPY.OOCOutputFile: tauon_at91sam9261.srec
  ILINK.IlinkIcfFile: C:\tauon\sys\user\tauon-basic\prj\iar\arch\arm\tauon-basic_at91sam9261\xcl_mac_at91sam9261\AT91SAM9261_SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration firmware_flash (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; USE_XGUI; DFLT_BRDBEEP_LVL=BRDBEEP_LVL_HIG
  ICCARM.CCIncludePath2: X:\sources\embOSARM7_332; X:\sources\embOSARM7_332\segger src\cpu; X:\sources\embOSARM7_332\segger src\generic; X:\sources; X:\sources\libc; X:\sources\libca; X:\sources\libmsr; X:\sources\lwip; X:\sources\lwip\include; X:\sources\lwip\ports\arm7; X:\sources\lwip\ports\arm7\include; X:\sources\lwip\include\ipv4
  AARM.ADefines: TARGET_ROM
configuration freertos-firmware_injector (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM9261 Atmel AT91SAM9261
  ICCARM.CCDefines: NDEBUG; SDRAM_TARGET=1; at91sam9261; flash_disable; sdram; SAM9XE_IAR
  ICCARM.CCDiagSuppress: pe001, pe375, pe177, pa050,Pe167
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/AtmelSAM9XE; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\boards\at91sam9261-ek; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\peripherals; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\utility
  ICCARM.CCOptLevel: 0
  AARM.ADefines: at91sam9261; TARGET_JTAG; at91sam9xe512_disable; sdram
  AARM.AUserIncludes: c:/tauon/sys/root/src
  OBJCOPY.OOCOutputFile: tauon_at91sam9261.srec
  ILINK.IlinkIcfFile: C:\tauon\sys\user\tauon-basic\prj\iar\arch\arm\tauon-basic_at91sam9261\xcl_mac_at91sam9261\AT91SAM9261_SDRAM_FREERTOS.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group tauon/lib
    ../../../../../../../root/prj/iar/arch/arm/dev/at91sam9261/lib-debug/lib/: dev_at91sam9261.a dev_at91sam9261_7.20.a
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7-9_388/lib/: os5t_al_isp.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/tauon-kernel-arm926ejs-freertos-debug/Exe/: tauon_6.21.a tauon_7.20.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/tauon-kernel-arm926ejs-debug/Exe/: tauon_6.21.a tauon_7.20.a
  group tauon/sys/root/bin
    ../../../../../../../root/src/bin/: test2.c
  group tauon/sys/root/bin/net
    ../../../../../../../root/src/bin/net/: lftpd.c telnetd.c
  group tauon/sys/root/bin/net/mongoose
    ../../../../../../../root/src/bin/net/mongoose/: mongoose.c mongoose.h mongoosed.c
  group tauon/sys/root/bin/tst
    ../../../../../../../root/src/bin/tst/: tsteth.c verifspi.c
  group tauon/sys/root/kernel/core/arch
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/embOSARM7-9_388/arch/cpu_at91sam9261
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7-9_388/arch/cpu_at91sam9261/: AT91SAM9261_Startup.s BootLoaderDF_AT91SAM9261.c BSP.c JLINKDCC_Process.c Main.c OS_Error.c RTOSINIT_AT91SAM9261.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSARM7_332/arch
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7_332/: Main.c
  group tauon/sys/root/kernel/core/ucore/embOSARM7_332/arch/cpu_at91sam9261
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7_332/arch/cpu_at91sam9261/: __low_level_init.c at91sam9261.h at91sam9261_board.h AT91SAM9261_Cstartup_V4.s79 AT91SAM9261_init.h lib_at91sam9261.h OS_Config.h RTOSINIT_AT91SAM9261.c
  group tauon/sys/root/kernel/core/ucore/embOSARM7_360/arch
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7_360/: at91sam9261_init.h BSP.h JLINKDCC.h Main.c OS_Config.h OS_Error.c RTOS.h
  group tauon/sys/root/kernel/core/ucore/embOSARM7_360/arch/cpu_at91sam9261
    ../../../../../../../root/src/kernel/core/ucore/embOSARM7_360/arch/cpu_at91sam9261/: __low_level_init.c at91sam9261.h at91sam9261_board.h AT91SAM9261_Cstartup_V4.s79 AT91SAM9261_init.h lib_at91sam9261.h OS_Config.h RTOSINIT_AT91SAM9261.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0/arch/arm9/at91sam9261
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/arm9/at91sam9261/: board.h board_cstartup_iar_sam9xe.s board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h board_powermode.c board_powermode.h main.c
  group tauon/sys/user/bin/net/cgi-bin
    ../../../../../src/bin/net/cgi-bin/: tstcgi.sh tstcgi2.c tstcgi2.sh tstpost.c tstpost.sh
  group tauon/sys/user/bin/net/html
    ../../../../../src/bin/net/html/: about.html index.html lepton.png lepton_mini.png
  group tauon/sys/user/dev/board_atmel_at91sam9261-ek
    ../../../../../src/dev/board_atmel_at91sam9261-ek/: dev_at91sam9261-ek_dm9000.c dev_at91sam9261-ek_lcd.c
