# IAR project tauon-basic_lm3s_6.21.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; DEBUG=1; ewarm; PART_LM3S9B96
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\../root/src/kernel/core/ucore/embOSCXM3_382/inc; ..\..\..\..\..\..\../root/src; ..\..\..\..\..\..\../root/src/kernel/net/lwip; ..\..\..\..\..\..\../root/src/kernel/net/lwip/include; ..\..\..\..\..\..\../root/src/kernel/net/lwip/ports/arm; ..\..\..\..\..\..\../root/src/kernel/net/lwip/ports/arm/include; ..\..\..\..\..\..\../root/src/kernel/net/lwip/include/ipv4; ..\..\..\..\..\..\../root/src/kernel/core/ucore/cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: tauon-basic_lm3s.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\user\tauon-basic\prj\iar\arch\arm\tauon-basic_lm3s\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCIncludePath2: ..\..\..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Start_LM3S9B96.out
  group tauon/bin
    ../../../../../../../root/src/bin/: udpsrvd.c
  group tauon/bin/dhrystone
    ../../../../../src/bin/dhrystone/: dhry.h dhry21a.c dhry21b.c dhrystone_main.c dhrystone_main.h timers.c
  group tauon/bin/free
    ../../../../../src/bin/free/: dlmalloc.c free_main.c
  group tauon/bin/sdramtest
    ../../../../../src/bin/sdramtest/: sdramtest_main.c
  group tauon/lib
    ../../../../../../../root/prj/iar/arch/arm/dev/lm3s/Debug/Exe/: dev_lm3s.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/lib-debug/lib/: tauon.a
  group tauon/sys/root/kernel/core/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/lm3s
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/lm3s/: lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/lm3s
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/lm3s/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/lm3s/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/lm3s/cpu/: BSP.c exceptions.h JLINKMEM_Process.c OS_Error.c RTOSINIT_LM3S9B96.c xmtx.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/lib
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/lib/: os7m_tl__dt.a os7m_tl__sp.a
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_384
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/lib/: os7m_tl__dt.a os7m_tl__r.a os7m_tl__sp.a
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/inc/: RTOS.h
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_384/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_384/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_384/lm3s
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/arch/lm3s/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_384/lm3s/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_384/arch/lm3s/cpu/: BSP.c exceptions.h JLINKMEM_Process.c OS_Error.c RTOSINIT_LM3S9B96.c RTOSVect.c xmtx.c xmtx2.c
