<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\dev\lm3s\dev_lm3s_6.21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\tauon\tauon_6.21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tauon-basic_lm3s_6.21.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all debug</name>
      <member>
        <project>tauon_6.21</project>
        <configuration>lib-debug</configuration>
      </member>
      <member>
        <project>dev_lm3s_6.21</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tauon-basic_lm3s_6.21</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


