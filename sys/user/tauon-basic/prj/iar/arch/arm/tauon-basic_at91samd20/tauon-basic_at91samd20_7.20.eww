<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\dev\at91samd20\dev_at91samd20_7.20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\tauon\tauon_7.20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tauon-basic_at91samd20_7.20.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>freertos-debug</name>
      <member>
        <project>dev_at91samd20_7.20</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tauon_7.20</project>
        <configuration>tauon-kernel-cortex-m0+-freertos-debug</configuration>
      </member>
      <member>
        <project>tauon-basic_at91samd20_7.20</project>
        <configuration>freertos-debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


