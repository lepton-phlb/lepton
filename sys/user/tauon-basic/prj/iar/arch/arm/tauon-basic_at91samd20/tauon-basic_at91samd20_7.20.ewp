# IAR project tauon-basic_at91samd20_7.20.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; DAC_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch\cortex-m0+\at91samd20; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/preprocessor; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards/samd20_xplained_pro; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/port; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/dac; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/tc; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt/system_interrupt_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/pinmux; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/events; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/boards; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/source; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/component; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/pio; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/instance; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/header_files; c:/tauon/sys/user/tauon-basic/src/dev/board_atmel_at91samd20-xplained-pro/asf/sam0/boards; c:/tauon/sys/user/tauon-basic/src/dev/board_atmel_at91samd20-xplained-pro/asf/sam0/boards/samd20_xplained_pro/board_config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch\cortex-m0+\at91samd20; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0
  OBJCOPY.OOCOutputFile: tauon-basic_at91samd20_7.20.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\tauon\sys\user\tauon-basic\prj\iar\arch\arm\tauon-basic_at91samd20\linker_scripts\samd20\iar\samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  group tauon/lib
    ../../../../../../../root/prj/iar/arch/arm/dev/at91samd20/Debug/Exe/: dev_at91samd20_7.20.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/tauon-kernel-cortex-m0+-freertos-debug/Exe/: tauon_7.20.a
  group tauon/sys/root/bin
    ../../../../../../../root/src/bin/: test2.c
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/atmel/samd20
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/source/: system_samd20.c system_samd20.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/atmel/samd20/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/source/iar/: startup_samd20.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0/arch/cortex-m0+
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m0+/at91samd20/: main.c
  group test
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/: croutine.c event_groups.c lepton_test.c list.c queue.c tasks.c timers.c
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/MemMang/: heap_3.c
  group test/portable
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
