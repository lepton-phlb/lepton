# IAR project tauon-basic_cmsis_6.21.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_LIBMODE_SP; DEBUG=1; ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\../root/src/kernel/core/ucore/embOSCXM3_382/inc; ..\..\..\..\..\..\../root/src; ..\..\..\..\..\..\../root/src/kernel/net/lwip; ..\..\..\..\..\..\../root/src/kernel/net/lwip/include; ..\..\..\..\..\..\../root/src/kernel/net/lwip/ports/arm; ..\..\..\..\..\..\../root/src/kernel/net/lwip/ports/arm/include; ..\..\..\..\..\..\../root/src/kernel/net/lwip/include/ipv4; ..\..\..\..\..\..\../root/src/kernel/core/ucore/cmsis; ..\..\..\..\..\..\..\root\src\kernel\core\ucore\cmsis\CMSIS\Include; ..\..\..\..\..\..\..\root\src\kernel\core\ucore\cmsis\Device\ARM\ARMCM3\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tauon-basic_cmsis_6.21.srec
  ILINK.IlinkOutputFile: Start_CMSIS.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\user\tauon-basic\prj\iar\arch\arm\tauon-basic_cmsis\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCIncludePath2: ..\..\..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Start_LM3S9B96.out
  group tauon/bin/dhrystone
    ../../../../../src/bin/dhrystone/: dhry.h dhry21a.c dhry21b.c dhrystone_main.c dhrystone_main.h timers.c
  group tauon/lib
    ../../../../../../../root/prj/iar/arch/arm/tauon/lib-debug/lib/: tauon.a
  group tauon/sys/root/kernel/core/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/CM3
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/ARM/ARMCM3/Include/: ARMCM3.h system_ARMCM3.h
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/ARM/ARMCM3/Source/Templates/: system_ARMCM3.c
  group tauon/sys/root/kernel/core/ucore/cmsis/device/lm3s
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/lm3s/: lm3s_cmsis.h system_lm3s.c system_lm3s.h
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/ARM/ARMCM3/Source/Templates/IAR/: startup_ARMCM3.s
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM3_382/lib
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM3_382/lib/: os7m_tl__sp.a
