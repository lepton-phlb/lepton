# Keil uVision project kernel.uvproj, settings and files
target kernel (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: kernel (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/net/uip2.5;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group core/arch/arm
    ../../../src/kernel/core/arch/arm/: kernel_mkconf.h dev_dskimg.h
  group core/core-segger
    ../../../src/kernel/core/core-segger/: syscall.c core_rttimer.c fork.c kernel.c kernel_clock.c kernel_elfloader.c kernel_object.c kernel_pthread.c kernel_pthread_mutex.c kernel_sem.c kernel_sigqueue.c kernel_timer.c process.c signal.c
  group core/net/uip_core
    ../../../src/kernel/core/net/uip_core/: uip_socket.h uip_core.c uip_core.h uip_dev_sock.c uip_dev_sock.h uip_slip.c uip_slip.h uip_sock.c uip_sock.h uip_socket.c
  group core/net
    ../../../src/kernel/core/net/: socks.h net.txt socket.h
  group core/sys
    ../../../src/kernel/core/sys/: utsname.h mqueue.h pthread.h semaphore.h siginfo.h sysctl.h
  group core
    ../../../src/kernel/core/: wait.c bin.c cpu.c devio.c dirent.c env.c fcntl.c flock.c kal.c lib.c malloc.c pipe.c posix_mqueue.c select.c stat.c statvfs.c sysctl.c system.c systime.c time.c timer.c truncate.c wait.h ver.h assert.h bin.h board.h core_event.h core_rttimer.h cpu.h devconf.h devio.h dirent.h env.h errno.h etypes.h fcntl.h flock.h fork.h interrupt.h io.h ioctl.h ioctl_board.h ioctl_cpu.h ioctl_eth.h ioctl_fb.h ioctl_hd.h ioctl_if.h ioctl_keyb.h ioctl_lcd.h ioctl_proc.h ioctl_pwr.h ioctl_usb.h kal.h kernel.h kernel_clock.h kernel_elfloader.h kernel_object.h kernel_pthread.h kernel_pthread_mutex.h kernel_sem.h kernel_sigqueue.h kernel_timer.h kernelconf.h lib.h libstd.h malloc.h net.h pipe.h posix_mqueue.h process.h rttimer.h select.h signal.h stat.h statvfs.h stropts.h syscall.h sysctl.h system.h systime.h time.h timer.h types.h heap.c
