# Keil uVision project fs.uvproj, settings and files
target fs (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: fs (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group vfs
    ../../../src/kernel/fs/vfs/: vfskernel.c vfs.c vfscore.c vfsdev.c vfstypes.h vfs.h vfscore.h vfsdev.h vfskernel.h
  group rootfs
    ../../../src/kernel/fs/rootfs/: rootfscore.h rootfs.c rootfs.h rootfscore.c
  group ufs
    ../../../src/kernel/fs/ufs/: ufsx.h ufs.c ufs.h ufscore.c ufscore.h ufsdriver.c ufsdriver.h ufsdriver_1_3.c ufsdriver_1_3.h ufsdriver_1_4.c ufsdriver_1_4.h ufsdriver_1_5.c ufsdriver_1_5.h ufsinfo.h ufsx.c
  group kofs
    ../../../src/kernel/fs/kofs/: kofs.h kofs.c
