# Keil uVision project sbin.uvproj, settings and files
target sbin (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: sbin (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group sbin
    ../../../src/sbin/: xmodem.c btb.c cat.c compress.c cp.c date.c df.c ecat.c echo.c initd.c kill.c lprintf.c ls.c lsh.c mkdir.c mkfifo.c mkfs.c more.c mount.c mv.c od.c ps.c pwd.c rm.c rmdir.c shutdown.c sleep.c stty.c sync.c touch.c umount.c uname.c wrapr.c
  group sbin/net
    ../../../src/sbin/net/: ifconfig.c
