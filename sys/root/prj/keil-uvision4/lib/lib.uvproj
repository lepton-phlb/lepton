# Keil uVision project lib.uvproj, settings and files
target lib (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: lib (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group lib/libc/ctype
    ../../../src/lib/libc/ctype/: ctype.h ctype.c
  group lib/libc/misc
    ../../../src/lib/libc/misc/: strto_ll.c crc.c crc.h dtostr.c ftoa.c ftoa.h itoa.c ltostr.c ltostr.h prsopt.c prsopt.h strto_l.c
  group lib/libc/stdio
    ../../../src/lib/libc/stdio/: stdio.h printf.c scanf.c stdio.c
  group lib/libc/termios
    ../../../src/lib/libc/termios/: termios.h tcgetattr.c tcsetattr.c termios.c
  group lib/libc/unistd
    ../../../src/lib/libc/unistd/: unistd.c getopt.c getopt.h
  group lib/libc/string
    ../../../src/lib/libc/string/: string.h string.c
  group lib/libc
    ../../../src/lib/libc/: stdint.h libc.c libc.h
