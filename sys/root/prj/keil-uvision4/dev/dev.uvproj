# Keil uVision project dev.uvproj, settings and files
target dev (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: dev (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP USE_STDPERIPH_DRIVER
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/net/uip2.5;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group arch/all/debug
    ../../../src/kernel/dev/arch/all/debug/: dev_os_debug.c dev_os_debug.h
  group arch/cmsis/dev_cmsis_cpu
    ../../../src/kernel/dev/arch/cmsis/dev_cmsis_cpu/: dev_cmsis_cpu.h dev_cmsis_cpu.c
  group arch/cmsis/dev_cmsis_itm
    ../../../src/kernel/dev/arch/cmsis/dev_cmsis_itm/: dev_cmsis_itm_0.c dev_cmsis_itm.c dev_cmsis_itm.h
  group dev_cpufs
    ../../../src/kernel/dev/dev_cpufs/: dev_cpufs.h dev_cpufs.c
  group dev_head
    ../../../src/kernel/dev/dev_head/: dev_head.c
  group dev_mem
    ../../../src/kernel/dev/dev_mem/: dev_mem.h dev_mem.c
  group dev_null
    ../../../src/kernel/dev/dev_null/: dev_null.c
  group dev_proc
    ../../../src/kernel/dev/dev_proc/: dev_proc.h dev_proc.c
  group dev_tty
    ../../../src/kernel/dev/dev_tty/: tty_font-8x16.c dev_tty.c
  group arch/all/ppp/dev_ppp_uip
    ../../../src/kernel/dev/arch/all/ppp/dev_ppp_uip/: ppp.h ahdlc.c ahdlc.h dev_ppp_uip.c dev_ppp_uip.h ipcp.c ipcp.h ipv6cp.c ipv6cp.h lcp.c lcp.h pap.c pap.h ppp.c
  group arch/cortexm/lm3s/dev_lm3s_cpu
    ../../../src/kernel/dev/arch/cortexm/stellaris/drivers/dev_lm3s_cpu/: dev_lm3s_cpu.h dev_lm3s_cpu.c
  group arch/cortexm/stm32f4xx/driverlib
    ../../../src/kernel/dev/arch/cortexm/stm32f4xx/driverlib/: stm32f4xx_usart.h stm32f4xx_usart.c stm32f4xx.h system_stm32f4xx.h misc.c misc.h Release_Notes.html stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_conf.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group arch/cortexm/stm32f4xx/dev_stm32f4xx
    ../../../src/kernel/dev/arch/cortexm/stm32f4xx/dev_stm32f4xx/: dev_stm32f4xx_uart_1.c dev_stm32f4xx_uart_x.h dev_stm32f4xx_uart_x.c dev_stm32f4xx_olimex_board.c dev_stm32f4xx_spi_x.h dev_stm32f4xx_spi_3.c dev_stm32f4xx_spi_x.c
  group arch/cortexm/stm32f4xx
    ../../../src/kernel/dev/arch/cortexm/stm32f4xx/: gpio.h gpio.c uart.h uart.c dma.h target.h types.h target.c spi.c
    ../../../../../../../root/src/kernel/dev/arch/cortexm/stm32f4xx/: spi.h
