# Keil uVision project net-uip.uvproj, settings and files
target net-uip (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: net-uip (library)
  c flags: Optim=1
  c define: OS_SUPPORT_CLEANUP_ON_TERMINATE OS_LIBMODE_SP
  c include: c:/tauon/sys/root/src;c:/tauon/sys/root/src/kernel/net/uip2.5;c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_386_keil/inc
  group net-uip/lib
    ../../../src/kernel/net/uip2.5/lib/: random.h list.c list.h memb.c memb.h random.c
  group net-uip/net
    ../../../src/kernel/net/uip2.5/net/: uip-udp-packet.h dhcpc.c dhcpc.h hc.c hc.h neighbor-attr.c neighbor-attr.h neighbor-info.c neighbor-info.h netstack.c netstack.h packetbuf.c packetbuf.h packetqueue.c packetqueue.h psock.c psock.h queuebuf.c queuebuf.h rawpacket.h rawpacket-udp.c rawpacket-udp.h resolv.c resolv.h rime.h sicslowpan.c sicslowpan.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcpdump.c tcpdump.h tcpip.c tcpip.h uaodv.c uaodv.h uaodv-def.h uaodv-rt.c uaodv-rt.h uip6.c uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip-debug.c uip-debug.h uip-ds6.c uip-ds6.h uip-fw.c uip-fw.h uip-fw-drv.c uip-fw-drv.h uip-icmp6.c uip-icmp6.h uiplib.c uiplib.h uip-nd6.c uip-nd6.h uip-neighbor.c uip-neighbor.h uipopt.h uip-over-mesh.c uip-over-mesh.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c
  group net-uip/sys
    ../../../src/kernel/net/uip2.5/sys/: timer_ip.c cc.h clock.c clock.h ctimer.c ctimer.h etimer.c etimer.h lc.h lc-addrlabels.h lc-switch.h process.h pt.h rtimer.c rtimer.h stimer.c stimer.h timer.c timer.h
  group net-uip
    ../../../src/kernel/net/uip2.5/: rtimer-arch.h contiki.h contiki-conf.h contiki-lib.h contiki-net.h contiki-version.h
