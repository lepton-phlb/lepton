# IAR project tauon.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: AT91SAM9261EK Atmel AT91SAM9261EK
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group kernel/core
    ../../../../../src/kernel/core/: bin.c bin.h board.h core_rttimer.h cpu.c cpu.h devconf.h devio.c devio.h dirent.c dirent.h env.c env.h errno.h etypes.h fcntl.c fcntl.h flock.c flock.h fork.h interrupt.h ioctl.h ioctl_board.h ioctl_cpu.h ioctl_hd.h ioctl_keyb.h ioctl_proc.h ioctl_pwr.h kal.h kernel.h kernel_pthread.h kernel_sem.h kernelconf.h lib.c libstd.h malloc.c malloc.h net.h pipe.c pipe.h posix_mqueue.c process.h rttimer.h select.c select.h signal.h stat.c stat.h statvfs.c statvfs.h syscall.h sysctl.c system.c system.h systime.c systime.h time.c time.h timer.c timer.h truncate.c types.h ver.h wait.c wait.h windef.h windows.h winnt.h
  group kernel/core/arch/arm
    ../../../../../src/kernel/core/arch/arm/: dev_dskimg.h kernel_mkconf.h
  group kernel/core/core-segger
    ../../../../../src/kernel/core/core-segger/: core_rttimer.c fork.c heap.c kernel.c kernel_clock.c kernel_elfloader.c kernel_object.c kernel_pthread.c kernel_pthread_mutex.c kernel_sem.c kernel_sigqueue.c kernel_timer.c process.c signal.c syscall.c
  group kernel/core/net
    ../../../../../src/kernel/core/net/: socket.h socks.h
  group kernel/core/net/lwip_core
    ../../../../../src/kernel/core/net/lwip_core/: ethif_core.c lwip_core.c lwip_core.h lwip_socket.c lwip_socket.h
  group kernel/core/net/uip_core
    ../../../../../src/kernel/core/net/uip_core/: uip_core.c uip_core.h uip_slip.c uip_slip.h uip_sock.c uip_sock.h uip_socket.c uip_socket.h
  group kernel/core/sys
    ../../../../../src/kernel/core/sys/: mqueue.h sysctl.h utsname.h
  group kernel/core/ucore/embOSARM7_332
    ../../../../../src/kernel/core/ucore/embOSARM7_332/: OS_Error.c RTOS.h RTOSVECT.asm
  group kernel/core/ucore/embOSARM7_332/src/cpu
    ../../../../../src/kernel/core/ucore/embOSARM7_332/src/cpu/: OS_Priv.h OSCHIP.h RTOS.asm
  group kernel/core/ucore/embOSARM7_332/src/generic
    ../../../../../src/kernel/core/ucore/embOSARM7_332/src/generic/: OS_Alloc.c OS_CreateTask.c OS_CreateTaskEx.c OS_CSEMA_SignalMax.c OS_DeactivateP.c OS_DeactivateTP.c OS_DeactivateTV.c OS_DeactivateV.c OS_EvaPacketEx.c OS_EVENT_Create.c OS_EVENT_Delete.c OS_EVENT_Get.c OS_EVENT_Pulse.c OS_EVENT_Reset.c OS_EVENT_Set.c OS_EVENT_Wait.c OS_EVENT_WaitTimed.c OS_GetNumTasks.c OS_GetPrio.c OS_GetSuspendCnt.c OS_HandleTick.c OS_MEMF_Alloc.c OS_MEMF_AllocTimed.c OS_MEMF_Create.c OS_MEMF_Delete.c OS_MEMF_Free.c OS_MEMF_Info.c OS_MEMF_Internal.c OS_MEMF_Release.c OS_MEMF_Request.c OS_RAW.h OS_SetCSemaValue.c OS_SetRxCallback.c OS_Suspend.c OS_TaskIndex2Ptr.c OS_Wait.c OSBuffer.c OSCHECK.c OSCMB.c OSCom.c OSCom1.c OSCom2.c OSComRxTx1.c OSCPU.c OSCPU1.c OSCSEM.c OSCSEMGV.c OSCSEMT.c OSDELCS.c OSDELM.c OSDelRS.c OSDummy.c OSEVENCL.c OSEVENGE.c OSEVENS.c OSEvenT.c OSEVENW.c OSEVENWS.c OSEvenWST.c OSGLOBAL.c OSGM.c OSGM1.c OSGMC.c OSGMC1.c OSGMT.c OSINFO.c OSInt.h OSIsTask.c OSKern.c OSMAIL.c OSMX.c OSPM.c OSPM1.c OSPMC.c OSPMC1.c OSPMF.c OSPMF1.c OSPMFC.c OSPMFC1.c OSQ.c OSQCL.c OSQGMC.c OSQGPC.c OSQGPT.c OSRR.c OSRSEM.c OSRSEMGO.c OSRSEMGV.c OSRSEMRQ.c OSSend.c OSSETP.c osstat.c OSStatGL.c OSTERM.c OSTermE.c OSTick.c OSTickDI.c OSTIME.c OSTIMED.c OSTIMEGP.c OSTIMEGS.c OSTIMEGV.c OSTIMERX.c OSTIMES.c OSTiming.c OSTrace.c OSTrace1.c OSWAKE.c OSWM.c
  group kernel/core/ucore/embOSARM7_360/src
    ../../../../../src/kernel/core/ucore/embOSARM7_360/: OS_Error.c RTOS.h
  group kernel/core/ucore/embOSARM7_360/src/cpu
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/cpu/: OS_Priv.h OSCHIP.h RTOS.asm
  group kernel/core/ucore/embOSARM7_360/src/cpu/ext
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/cpu/ext/: OS_ARM720_MMU.c OS_ARM_MMU.c OS_VFP.c
  group kernel/core/ucore/embOSARM7_360/src/generic
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/generic/: OS_Alloc.c OS_CreateTask.c OS_CreateTaskEx.c OS_CSEMA_SignalMax.c OS_DeactivateP.c OS_DeactivateTP.c OS_DeactivateTV.c OS_EvaPacketEx.c OS_EVENT_Create.c OS_EVENT_Delete.c OS_EVENT_Get.c OS_EVENT_Pulse.c OS_EVENT_Reset.c OS_EVENT_Set.c OS_EVENT_Wait.c OS_EVENT_WaitTimed.c OS_GetNumTasks.c OS_GetPrio.c OS_GetSize.c OS_GetSuspendCnt.c OS_HandleTick.c OS_HandleTick_Ex.c OS_MEMF_Alloc.c OS_MEMF_AllocTimed.c OS_MEMF_Create.c OS_MEMF_Delete.c OS_MEMF_Free.c OS_MEMF_Info.c OS_MEMF_Internal.c OS_MEMF_Release.c OS_MEMF_Request.c OS_Power.c OS_RAW.h OS_SetCSemaValue.c OS_SetRxCallback.c OS_SetTaskName.c OS_Suspend.c OS_TaskIndex2Ptr.c OS_TickHook.c OS_Wait.c OS_Yield.c OSBuffer.c OSCHECK.c OSCMB.c OSCom.c OSCom1.c OSCom2.c OSComRxTx1.c OSCPU.c OSCPU1.c OSCSEM.c OSCSEMGV.c OSCSEMRQ.c OSCSEMT.c OSDELCS.c OSDELM.c OSDelRS.c OSDummy.c OSEVENCL.c OSEVENGE.c OSEVENS.c OSEvenT.c OSEVENW.c OSEVENWS.c OSEvenWST.c OSGLOBAL.c OSGM.c OSGM1.c OSGMC.c OSGMC1.c OSGMT.c OSINFO.c OSInt.h OSIsTask.c OSKern.c OSMAIL.c OSMX.c OSPM.c OSPM1.c OSPMC.c OSPMC1.c OSPMF.c OSPMF1.c OSPMFC.c OSPMFC1.c OSQ.c OSQCL.c OSQGMC.c OSQGPC.c OSQGPT.c OSRR.c OSRSEM.c OSRSEMGO.c OSRSEMGV.c OSRSEMRQ.c OSSend.c OSSETP.c osstat.c OSStatGL.c OSTERM.c OSTermE.c OSTickDI.c OSTickDI_Ex.c OSTIME.c OSTIMED.c OSTIMEGP.c OSTIMEGS.c OSTIMEGV.c OSTIMERX.c OSTIMES.c OSTiming.c OSTrace.c OSTrace1.c OSWAKE.c OSWM.c
  group kernel/dev/arch/all/eth/dev_eth_dm9000a
    ../../../../../src/kernel/dev/arch/all/eth/dev_eth_dm9000a/: dev_eth_dm9000a.c
  group kernel/dev/arch/all/flash
    ../../../../../src/kernel/dev/arch/all/flash/: flash.c flash.h
  group kernel/dev/arch/all/flash/amd
    ../../../../../src/kernel/dev/arch/all/flash/amd/: dev_flash_am29dlxxxx_1.c dev_flash_am29dlxxxx_2.c dev_flash_am29dlxxxx_3.c dev_flash_nor_amd.c dev_flash_nor_amd.h
  group kernel/dev/arch/all/flash/amd/lldapi
    ../../../../../src/kernel/dev/arch/all/flash/amd/lldapi/: lld.c lld.h lld_target_specific.h trace.c trace.h
  group kernel/dev/arch/all/flash/dev_ftl
    ../../../../../src/kernel/dev/arch/all/flash/dev_ftl/: dev_ftl.c
  group kernel/dev/arch/all/i2c
    ../../../../../src/kernel/dev/arch/all/i2c/: dev_eeprom_24xxx.c dev_eeprom_24xxx.h dev_eeprom_24xxx_0.c
  group kernel/dev/arch/all/sdcard
    ../../../../../src/kernel/dev/arch/all/sdcard/: dev_sdcard.c dev_sdcard.h drv_sdcard.c drv_sdcard.h drv_sdcard_arch.h
  group kernel/dev/arch/all/slip
    ../../../../../src/kernel/dev/arch/all/slip/: dev_slip.c
  group kernel/dev/arch/arm7/dev_at91
    ../../../../../src/kernel/dev/arch/arm7/dev_at91/: dev_at91.c dev_at91.h
  group kernel/dev/dev_cpufs
    ../../../../../src/kernel/dev/dev_cpufs/: dev_cpufs.c dev_cpufs.h
  group kernel/dev/dev_head
    ../../../../../src/kernel/dev/dev_head/: dev_head.c
  group kernel/dev/dev_mem
    ../../../../../src/kernel/dev/dev_mem/: dev_mem.c dev_mem.h
  group kernel/dev/dev_null
    ../../../../../src/kernel/dev/dev_null/: dev_null.c dev_null.h
  group kernel/dev/dev_proc
    ../../../../../src/kernel/dev/dev_proc/: dev_proc.c dev_proc.h
  group kernel/dev/dev_tty
    ../../../../../src/kernel/dev/dev_tty/: dev_tty.c tty_font-8x16.c
  group kernel/fs/kofs
    ../../../../../src/kernel/fs/kofs/: kofs.c kofs.h
  group kernel/fs/rootfs/includes
    ../../../../../src/kernel/fs/rootfs/: rootfs.h rootfscore.h
  group kernel/fs/rootfs/sources
    ../../../../../src/kernel/fs/rootfs/: rootfs.c rootfscore.c
  group kernel/fs/ufs/includes
    ../../../../../src/kernel/fs/ufs/: ufs.h ufscore.h ufsdriver.h ufsdriver_1_3.h ufsdriver_1_4.h ufsdriver_1_5.h ufsinfo.h ufsx.h
  group kernel/fs/ufs/sources
    ../../../../../src/kernel/fs/ufs/: ufs.c ufscore.c ufsdriver.c ufsdriver_1_3.c ufsdriver_1_4.c ufsdriver_1_5.c ufsx.c
  group kernel/fs/vfs/includes
    ../../../../../src/kernel/fs/vfs/: vfs.h vfscore.h vfsdev.h vfskernel.h vfstypes.h
  group kernel/fs/vfs/sources
    ../../../../../src/kernel/fs/vfs/: vfs.c vfscore.c vfsdev.c vfskernel.c
  group kernel/net/lwip/api
    ../../../../../src/kernel/net/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
  group kernel/net/lwip/core
    ../../../../../src/kernel/net/lwip/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group kernel/net/lwip/core/ipv4
    ../../../../../src/kernel/net/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group kernel/net/lwip/netif
    ../../../../../src/kernel/net/lwip/netif/: etharp.c loopif.c slipif.c
  group kernel/net/lwip/ports/arm
    ../../../../../src/kernel/net/lwip/ports/arm/: lwipopts.h sys_arch.c
  group kernel/net/lwip/ports/arm/include/arch
    ../../../../../src/kernel/net/lwip/ports/arm/include/arch/: bpstruct.h cc.h epstruct.h perf.h sys_arch.h
  group lib/libc
    ../../../../../src/lib/libc/: libc.c libc.h stdint.h
  group lib/libc/ctype
    ../../../../../src/lib/libc/ctype/: ctype.c ctype.h
  group lib/libc/misc
    ../../../../../src/lib/libc/misc/: crc.c crc.h dtostr.c ftoa.c ftoa.h itoa.c ltostr.c ltostr.h prsopt.c prsopt.h strto_l.c
  group lib/libc/stdio
    ../../../../../src/lib/libc/stdio/: printf.c scanf.c stdio.c stdio.h
  group lib/libc/termios
    ../../../../../src/lib/libc/termios/: tcgetattr.c tcsetattr.c termios.c termios.h
  group lib/libc/unistd
    ../../../../../src/lib/libc/unistd/: getopt.c getopt.h unistd.c
  group lib/librt
    ../../../../../src/lib/librt/: mq.c mqueue.h sem.c semaphore.h
  group lib/pthread
    ../../../../../src/lib/pthread/: pthread.c pthread.h pthread_cond.c pthread_mutex.c
  group sbin
    ../../../../../src/sbin/: btb.c cat.c compress.c cp.c date.c df.c ecat.c echo.c initd.c kill.c ls.c lsh.c mkdir.c mkfifo.c mkfs.c more.c mount.c mv.c od.c ps.c pwd.c rm.c rmdir.c shutdown.c sleep.c stty.c sync.c touch.c umount.c uname.c wrapr.c xmodem.c
  group sbin/net
    ../../../../../src/sbin/net/: ifconfig.c slipd.c
