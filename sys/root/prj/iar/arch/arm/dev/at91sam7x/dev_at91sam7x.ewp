# IAR project dev_at91sam7x.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group kernel/dev/arch/arm7/at91sam7x/common
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/common/: dev_at91sam7x_common.h dev_at91sam7x_common_uart.h
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_cpu
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_cpu/: dev_at91sam7x_cpu.c dev_at91sam7x_cpu.h
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_emac
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_emac/: dev_at91sam7x_emac.c dev_at91sam7x_phy.c dev_at91sam7x_phy.h dev_ks8721bl_phy.c dev_ks8721bl_phy.h dm9161_define.h
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_rtt
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_rtt/: dev_at91sam7x_rtt.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_spi
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_spi/: dev_at91sam7x_spi.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_twi
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_twi/: at91sam7x_twi_io.c at91sam7x_twi_io.h dev_at91sam7x_twi.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_0
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_0/: dev_at91sam7x_uart_0.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_1
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_1/: dev_at91sam7x_uart_1.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_dbg
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_dbg/: dev_at91sam7x_uart_dbg.c
  group kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_x
    ../../../../../../src/kernel/dev/arch/arm7/at91sam7x/dev_at91sam7x_uart_x/: dev_at91sam7x_uart_dbg_x.c dev_at91sam7x_uart_x.c dev_at91sam7x_uart_x.h
