# IAR project dev_at91m55800a.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: AT91M55800 Atmel AT91M55800
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_332; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_332/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_332/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_eth_cs8900
    ../../../../../../src/kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_eth_cs8900/: dev_at91m55800a_eth_cs8900.c
  group kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_rtc
    ../../../../../../src/kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_rtc/: dev_at91m55800a_rtc.c
  group kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s0
    ../../../../../../src/kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s0/: dev_at91m55800a_uart_s0.c dev_at91m55800a_uart_s0.h
  group kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s1
    ../../../../../../src/kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s1/: dev_at91m55800a_uart_s1.c dev_at91m55800a_uart_s1.h
  group kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s2
    ../../../../../../src/kernel/dev/arch/arm7/at91m55800a/dev_at91m55800a_uart_s2/: dev_at91m55800a_uart_s2.c dev_at91m55800a_uart_s2.h
