<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dev_at91m55800a.ewp</path>
  </project>
  <batchBuild/>
</workspace>


