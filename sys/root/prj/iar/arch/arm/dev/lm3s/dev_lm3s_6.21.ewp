# IAR project dev_lm3s_6.21.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; TARGET_IS_TEMPEST_RB1; PART_LM3S9D96
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\src\kernel\dev\arch\cortexm\stellaris\; ..\..\..\..\..\..\src/kernel/core/ucore/embOSCXM3_382/inc; ..\..\..\..\..\..\src; ..\..\..\..\..\..\src/dev/arch/cortexm\stellaris/driverlib
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib.srec
  ILINK.IlinkOutputFile: driverlib.out
  group driverlib
    ../../../../../../src/kernel/dev/arch/cortexm/stellaris/driverlib/: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group drivers
    ../../../../../../src/kernel/dev/arch/cortexm/stellaris/drivers/: lm3s_reset.c lm3s_sdram.c
  group drivers/dev_lm3s_uart
    ../../../../../../src/kernel/dev/arch/cortexm/stellaris/drivers/dev_lm3s_uart/: dev_lm3s_uart.c dev_lm3s_uart.h dev_lm3s_uart_0.c
