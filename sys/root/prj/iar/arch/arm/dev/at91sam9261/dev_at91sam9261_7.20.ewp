# IAR project dev_at91sam9261_7.20.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9261 Atmel AT91SAM9261
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; SDRAM_TARGET=1; at91sam9261
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/AtmelSAM9XE; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7-9_388/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\boards\at91sam9261-ek; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\peripherals; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\utility
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_at91sam9261.out
  group kernel/dev/arch/arm9/at91sam9261/at91lib/aic
    ../../../../../../src/kernel/dev/arch/at91/at91lib/peripherals/aic/: aic.c aic.h
  group kernel/dev/arch/arm9/at91sam9261/at91lib/pit
    ../../../../../../src/kernel/dev/arch/at91/at91lib/peripherals/pit/: pit.c pit.h
  group kernel/dev/arch/arm9/at91sam9261/common
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/common/: dev_at91sam9261_common.h dev_at91sam9261_common_uart.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_cpu
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_cpu/: dev_at91sam9261_cpu.c dev_at91sam9261_cpu.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_eth_dm9000a
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_eth_dm9000a/: dev_at91sam9261_eth_dm9000a.c dev_at91sam9261_eth_dm9000a.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_lcd
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_lcd/: at91sam9261_lcd.c at91sam9261_lcd.h at91sam9261_lcd_lut.h dev_at91sam9261_lcd.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtt
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtt/: dev_at91sam9261_rtt.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_spi
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_spi/: dev_at91sam9261_spi.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_twi
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_twi/: at91sam9261_twi_io.c at91sam9261_twi_io.h dev_at91sam9261_twi.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_0
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_0/: dev_at91sam9261_uart_0.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_1
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_1/: dev_at91sam9261_uart_1.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_dbg
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_dbg/: dev_at91sam9261_uart_dbg.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_x
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_x/: dev_at91sam9261_uart_dbg_x.c dev_at91sam9261_uart_x.c dev_at91sam9261_uart_x.h
