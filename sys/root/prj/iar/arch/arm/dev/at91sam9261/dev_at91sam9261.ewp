# IAR project dev_at91sam9261.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: AT91SAM9261 Atmel AT91SAM9261
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group kernel/dev/arch/arm9/at91sam9261/common
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/common/: dev_at91sam9261_common.h dev_at91sam9261_common_uart.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_cpu
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_cpu/: dev_at91sam9261_cpu.c dev_at91sam9261_cpu.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_lcd
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_lcd/: at91sam9261_lcd.c at91sam9261_lcd.h at91sam9261_lcd_lut.h dev_at91sam9261_lcd.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtt
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtt/: dev_at91sam9261_rtt.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_0
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_0/: dev_at91sam9261_rtu_0.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_1
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_1/: dev_at91sam9261_rtu_1.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_2
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_2/: dev_at91sam9261_rtu_2.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_x
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_rtu_x/: dev_at91sam9261_rtu_x.c dev_at91sam9261_rtu_x.h
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_spi
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_spi/: dev_at91sam9261_spi.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_twi
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_twi/: at91sam9261_twi_io.c at91sam9261_twi_io.h dev_at91sam9261_twi.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_0
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_0/: dev_at91sam9261_uart_0.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_1
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_1/: dev_at91sam9261_uart_1.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_dbg
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_dbg/: dev_at91sam9261_uart_dbg.c
  group kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_x
    ../../../../../../src/kernel/dev/arch/arm9/at91sam9261/dev_at91sam9261_uart_x/: dev_at91sam9261_uart_dbg_x.c dev_at91sam9261_uart_x.c dev_at91sam9261_uart_x.h
