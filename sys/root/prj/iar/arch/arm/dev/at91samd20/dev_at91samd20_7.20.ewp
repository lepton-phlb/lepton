# IAR project dev_at91samd20_7.20.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; _BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; USART_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/preprocessor; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards/samd20_xplained_pro; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/port; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/sercom; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/tc; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt/system_interrupt_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/pinmux; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/events; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/boards; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/source; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/component; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/pio; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/instance; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/header_files; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/module_config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group dev/arch/at91/asf/common/utils/interrupt
    ../../../../../../src/kernel/dev/arch/at91/asf/common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group dev/arch/at91/asf/sam0/drivers/port
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/port/: port.c port.h
  group dev/arch/at91/asf/sam0/drivers/sercom
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/sercom/: sercom.c sercom.h sercom_interrupt.c sercom_interrupt.h sercom_pinout.h
  group dev/arch/at91/asf/sam0/drivers/sercom/usart
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/sercom/usart/: usart.c usart.h usart_interrupt.c usart_interrupt.h
  group dev/arch/at91/asf/sam0/drivers/system
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/: system.c system.h
  group dev/arch/at91/asf/sam0/drivers/system/clock
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/: gclk.c
  group dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/: clock.c clock_config_check.h
  group dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/module_config
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/module_config/: conf_clocks.h
  group dev/arch/at91/asf/sam0/drivers/system/interrupt
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group dev/arch/at91/asf/sam0/drivers/system/pinmux
    ../../../../../../src/kernel/dev/arch/at91/asf/sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group dev/arch/cortexm/at91samd20/at91samd20_uart
    ../../../../../../src/kernel/dev/arch/cortexm/at91samd20/at91samd20_uart/: dev_at91samd20_uart_3.c dev_at91samd20_uart_x.c dev_at91samd20_uart_x.h
  group dev/arch/cortexm/at91samd20/at91samd20_xplained_pro_board
    ../../../../../../src/kernel/dev/arch/cortexm/at91samd20/at91samd20_xplained_pro_board/: at91samd20_xplained_pro_board.h at91samd20_xplained_pro_board_clock.c at91samd20_xplained_pro_board_conf_clocks.h at91samd20_xplained_pro_board_init.c dev_at91samd20_xplained_pro_board.c
